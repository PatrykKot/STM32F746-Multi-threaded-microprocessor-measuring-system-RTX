# Keil uVision project HTTP_Server.uvprojx, settings and files
target STM32F746 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4
  c include: .\IncludeUser;.\LwIP Config;.\LwIP2\include;.\LwIP2\include\netif;.\LwIP2\include\posix;.\LwIP2\ports\cmsis-rtos\include;.\LwIP2\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group SourceUser
    ./SourceUser/: main.c mcuConfig.c lcdLogger.c usrTasks.c audioRecording.c stm32f7xx_it.c soundProcessing.c
  group IncludeUser
    ./IncludeUser/: main.h mcuConfig.h lcdLogger.h usrTasks.h audioRecording.h stm32f7xx_it.h soundProcessing.h
  group Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_lcd.c stm32746g_discovery_audio.c stm32746g_discovery.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/BSP/Components/wm8994/: wm8994.c
  group Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.8.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c.c stm32f7xx_hal_uart.c stm32f7xx_hal_tim_ex.c
  group DSP
    ./DSP/: arm_cortexM7l_math.lib
  group LwIP Config
    ./LwIP Config/: ethernetif.c ethernetif.h lwip.c lwipopts.h lwip.h
  group LwIP
    ./LwIP2/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ./LwIP2/core/: def.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./LwIP2/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ./LwIP2/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ./LwIP2/netif/: etharp.c slipif.c
    ./LwIP2/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ./LwIP2/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ./LwIP2/ports/cmsis-rtos/: sys_arch.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Network:CORE 6.7.0, Network:Interface:ETH 6.7.0, Network:Service:Web Server Compact 6.7.0, Network:Socket:TCP 6.7.0, Network:Socket:UDP 6.7.0, Board Support:Buttons 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.3, CMSIS Driver:Ethernet PHY:LAN8742A 1.1, Device:STM32Cube Framework:Classic 1.1.2, Device:STM32Cube HAL:ADC 1.1.2, Device:STM32Cube HAL:Common 1.1.2, Device:STM32Cube HAL:Cortex 1.1.2, Device:STM32Cube HAL:DMA 1.1.2, Device:STM32Cube HAL:GPIO 1.1.2, Device:STM32Cube HAL:LTDC 1.1.2, Device:STM32Cube HAL:PWR 1.1.2, Device:STM32Cube HAL:RCC 1.1.2, Device:STM32Cube HAL:SDRAM 1.1.2, Device:STM32Cube HAL:SRAM 1.1.2, Device:Startup 1.1.2
